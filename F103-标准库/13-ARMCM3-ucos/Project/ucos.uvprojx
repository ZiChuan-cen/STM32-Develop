# Keil uVision project ucos.uvprojx, settings and files
target ARMCM3-Ucos (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ucos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\User\Ucos-CPU;..\User\Ucos-III;..\User\Ucos-III\Source;..\User\Ucos-III\Ports;..\User\Ucos-LIB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: app.c
  group uC/OS-III Source
    ../User/Ucos-III/Source/: os_type.h os_cfg.h os.h os_core.c os_task.c os_var.c
  group uC/OS-III Ports
    ../User/Ucos-III/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC/CPU
    ../User/Ucos-CPU/: cpu.h
  group Doc
    ../Doc/: Readme.txt
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.2
