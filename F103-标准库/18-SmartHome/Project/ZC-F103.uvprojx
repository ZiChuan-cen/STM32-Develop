# Keil uVision project ZC-F103.uvprojx, settings and files
target SmartHome (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smart-plant
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\sys;..\User\delay;..\Device\USART;..\Device\ADC;..\Device\DHT11;..\Device\FLASH;..\Device\IO;..\Device\LCD12864;..\Device\TIM;..\Device\WIFI;..\Device\OLED;..\Device\WT588
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Device
    ../Device/ADC/: adc.c
    ../Device/DHT11/: dht11.c
    ../Device/FLASH/: stmflash.c
    ../Device/IO/: io.c
    ../Device/LCD12864/: lcd12864.c
    ../Device/TIM/: timer.c
    ../Device/WIFI/: esp8266.c
    ../Device/Usart/: usart.c
    ../Device/WT588/: trum.c
    ../Device/OLED/: oled.c
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c
    ../User/delay/: delay.c
    ../User/sys/: sys.c
  group DOC
    ../DOC/: 必读文档.txt
